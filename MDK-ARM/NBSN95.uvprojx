# Keil uVision project NBSN95.uvprojx, settings and files
target NBSN95 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L072CZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: NBSN95 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx,NSE01
  c include: ../Inc;                          ../Drivers/STM32L0xx_HAL_Driver/Inc;                          ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;                          ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;                          ../Drivers/CMSIS/Include;                          ..\Drivers\BSP\inc;                          ..\Drivers\LWM2M
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c iwdg.c usart.c rtc.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/BSP
    ../Drivers/BSP/src/: at.c battery_read.c common.c flash_eraseprogram.c lowpower.c time_server.c ds18b20.c ult.c txs0102.c soil.c
  group Drivers/NBIOT
    ../Drivers/BSP/src/: nbInit.c nb_mqtt.c nb_udp.c nb_coap.c nb_tcp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group NOTES
    ../NOTES/: recording.txt readMe.txt
software components: CMSIS:CORE 5.4.0
